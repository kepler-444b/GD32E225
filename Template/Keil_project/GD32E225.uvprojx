# Keil uVision project GD32E225.uvprojx, settings and files
target GD32E23x (6240000::V6.24::ARMCLANG)
  device: GD32E225CB GigaDevice
  pack: GigaDevice.GD32E23x_DFP.2.3.2
  cpu: IRAM(0x20000000,0x0004000) IROM(0x08000000,0x0020000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E225
  c include: ..\..\Firmware\CMSIS;..\..\Utilities;..\;..\..\Utilities\LCD_Commom;..\..\Firmware\GD32E23x_standard_peripheral\Include;..\..\Firmware\CMSIS\GD\GD32E23x\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application
    ../: gd32e23x_it.c main.c systick.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32E23x/Source/: system_gd32e23x.c
  group Peripherals
    ../../Firmware/GD32E23x_standard_peripheral/Source/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32E23x/Source/ARM/: startup_gd32e23x.s
  group Utilities
    ../../Utilities/: gd32e230c_eval.c
  group Doc
    ../: readme.txt
  group plcp_common
    ../../Source/plcp_common/Inc/: APP_RxBuffer.h APP_TxBuffer.h Common.h lmexxx_conf.h Uapps.h
    ../../Source/plcp_common/Src/: APP_PublicAttribute.c APP_RxBuffer.c APP_TxBuffer.c LmeUtils.c Uapps.c UappsRSL.c
  group plcp_device
    ../../Source/plcp_device/plcp_panel/: plcp_panel.c plcp_panel.h plcp_panel_api.c plcp_panel_api.h plcp_panel_info.c plcp_panel_info.h attr_table.c attr_table.h panel_adapter.c panel_adapter.h
    ../../Source/plcp_device/: APP_PublicAttribute.h APP_UserProcess.c CmdDemo.c MseProcess.c MseProcess.h UappsProduct_Init.c
    ../../Source/plcp_device/plcp_linght_ct/: light_ct_adapter.c light_ct_adapter.h light_ct_attr_table.c light_ct_attr_table.h plcp_light_ct.c plcp_light_ct.h plcp_light_ct_info.c plcp_light_ct_info.h
  group cJSON
    ../../Source/cJSON/: cJSON.c cJSON.h cJSON_Utils.c cJSON_Utils.h
  group base
    ../../Source/base/: base.c base.h debug.h panel_base.c panel_base.h
  group common
    ../../Source/adc/: adc.c adc.h
    ../../Source/gpio/: gpio.c gpio.h
    ../../Source/protocol/: protocol.c protocol.h
    ../../Source/flash/: flash.c flash.h
    ../../Source/eventbus/: eventbus.c eventbus.h
    ../../Source/pwm/: curve_table.h pwm.c pwm.h pwm_hw.c pwm_hw.h
    ../../Source/watchdog/: watchdog.c watchdog.h
    ../../Source/zero/: zero.c zero.h
    ../../Source/usart/: usart.c usart.h
    ../../Source/timer/: timer.c timer.h
  group device_manager
    ../../Source/device/: device_manager.h jump_device.c jump_device.h
  group plcp_user_api
    ../../Source/plcp_device/plcp_user_api/: PLCP_bind.c PLCP_bind.h PLCP_callback.c PLCP_callback.h PLCP_scene.c PLCP_scene.h PLCP_sdk_api.c PLCP_sdk_api.h PLCP_special_scene.c PLCP_special_scene.h
  group RTT
    ../../Source/rtt/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
software components: CMSIS:CORE 6.1.1
